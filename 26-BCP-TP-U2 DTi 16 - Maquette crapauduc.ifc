Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: Off], Option [IFC Space boundaries: Off], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\Users\julien\Documents\Lycée\Bac Pro TP\Sujet 2026 (a créer)\SUJET BAC PRO 2026\Canniveaux .ifc
Time: 2024-06-24T17:47:59
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by Graphisoft Archicad 26.0.0 FRA FULL Windows version (IFC add-on version: 3001 FRA FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: 48, 51, 12, 248500; RefLongitude: 2, 20, 55, 625630; RefElevation: 400 m

# IfcBuildingStorey (2)
In: Bâtiment
Name | Elevation (m)
Sous-sol | -2.8
Rez-de-chaussée | 0

# IfcBuildingElementProxy: Fer (3)
In: Sous-sol
Type - ElementType: MORPH; PredefinedType: USERDEFINED
Classification: Forme (Classification Archicad); Material: Fer
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Volume - Etude (14)
In: Rez-de-chaussée
Type - ElementType: MORPH; PredefinedType: USERDEFINED
Classification: Forme (Classification Archicad); Material: Volume - Etude
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
7 x FORME-025
7 x FORME-040
